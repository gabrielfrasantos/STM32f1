<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EXTI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Temperature_Sensor\EWARM\temperature.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\USART\EWARM\USART.ewp</path>
    </project>
    <batchBuild />
</workspace>
